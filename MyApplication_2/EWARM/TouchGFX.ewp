# IAR project TouchGFX.ewp, settings and files
configuration TouchGFX-STM32H747I-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_CM7 ST STM32H747XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; BSP_USE_CMSIS_OS; CORE_CM7; USE_BPP=16; ST; USE_FLOATING_POINT; USE_USB_HS; USE_PWR_LDO_SUPPLY__N
  ICCARM.CCIncludePath2: ../TouchGFX/generated/images/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/gui/include; ..\TouchGFX\gui\include\gui\audio_player_screen; ../Middlewares/ST/TouchGFX/touchgfx/framework/include; ..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\Drivers\BSP\STM32H747I-Discovery; ..\Utilities\JPEG; ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\Middlewares\Third_Party\FatFs\src; ..\Middlewares\Third_Party\FatFs\src\drivers; ..\Middlewares\Third_Party\LibJPEG\include; ..\Config; ..\Core\Inc; ..\Drivers\CMSIS\Include; ..; ..\TouchGFX\target; ..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc; ..\..\STFirmware\Common\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\Config
  OBJCOPY.OOCOutputFile: TouchGFX.hex
  ILINK.IlinkOutputFile: TouchGFX-STM32H747I-DISCO_V1.0.0.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08000000
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: stm32h7xx_CM7_FLASH.icf
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h747xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_25_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_25_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_25_4bpp.cpp Table_verdana_40_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/screen1_screen
    ../TouchGFX/generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/screen2_screen
    ../TouchGFX/generated/gui_generated/src/screen2_screen/: Screen2ViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: background_Screen1.cpp background_Screen2.cpp BitmapDatabase.cpp btn_round.cpp btn_round_pressed.cpp configuration.cpp Down_arrow.cpp Down_arrow_pressed.cpp Up_arrow.cpp Up_arrow_pressed.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/gui/screen1_screen
    ../TouchGFX/gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
  group Application/User/TouchGFX/gui/screen2_screen
    ../TouchGFX/gui/src/screen2_screen/: Screen2Presenter.cpp Screen2View.cpp
  group Drivers/BSP
    ../Drivers/BSP/STM32H747I-Discovery/: stm32h747i_discovery.c stm32h747i_discovery_qspi.c stm32h747i_discovery_sd.c stm32h747i_discovery_sdram.c stm32h747i_discovery_ts.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_bdma.c stm32h7xx_ll_crc.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_lptim.c stm32h7xx_ll_mdma.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_usb.c
  group Middleware/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/FreeRTOS/CMSIS_RTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middleware/FreeRTOS/MemMgr
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middleware/FreeRTOS/Portable
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middleware/TouchGFX/Lib
    ../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/IAR8.x/: touchgfx_core_release.a
  group Middleware/TouchGFX/OS
    ../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers_cmsis.cpp
  group Middleware/TouchGFX/Target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp STM32H747TouchController.cpp STM32H7DMA.cpp STM32H7HAL_DSI.cpp STM32H7Instrumentation.cpp
